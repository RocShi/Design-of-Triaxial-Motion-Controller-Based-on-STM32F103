# Keil uVision project ShiPeng.uvproj, settings and files
target DebugInFlash (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ShiPeng +hex
  c flags: Optim=1 OneElfS=1
  c include: .\startup;.\driver\stm32lib\inc;.\user;.\driver\SP_GPIO_Init;.\driver\Motor;.\driver\Delay;.\driver\KeyBoard;.\driver\Interpolation;.\driver\PositionConstraint
  asm include: .\startup
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./startup/: startup.s target.c
  group stmlib
    ./driver/stm32lib/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_pwr.c
  group SP_GPIO.Init
    ./driver/SP_GPIO_Init/: SP_GPIO_Init.c
  group Motor
    ./driver/Motor/: Motor.c
  group Delay
    ./driver/Delay/: Delay.c
  group KeyBoard
    ./driver/KeyBoard/: KeyBoard.c
  group Interpolation
    ./driver/Interpolation/: Interpolation.c
  group PositionConstraint
    ./driver/PositionConstraint/: PositionConstraint.c
  group user
    ./user/: main.c
